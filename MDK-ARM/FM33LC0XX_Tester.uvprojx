# Keil uVision project FM33LC0XX_Tester.uvprojx, settings and files
target Example (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LC04X FMSH
  pack: FMSH.FM33LC0XX_DFP.3.0.4
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33LC0xx_Tester +hex
  AfterMake: fromelf.exe   --bin -o  .\OK_BIN\TP2801.bin  Objects\FM33LC0xx_Tester.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LC0xx_LL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM0;..\Mytask\usart2;..\Mytask\device;..\Mytask\freertostask;..\Mytask\flash;..\Mytask\hist;..\Mytask\w24q32;..\Mytask\NB;..\Mytask\lora;..\Mytask\jhm1200;..\Mytask\modbus;..\Mytask\EC20_4g;..\Mytask\AT;..\Mytask\timestamp;..\Mytask\pwr;..\Mytask\w24q32;..\Mytask\RTC;..\Mytask\EC20_4g;..\Mytask\lorawan_yxd;..\Mytask\DS18B20;..\Mytask\LCD;..\Mytask\isl1208;..\Mytask\CS5560
  memory RVCT4: ROM 0x2800 size 0x3d800
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: adc.c flash.c gpio.c main.c spi.c uart.c user_init.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group Drivers/FM33LC0xx_LL_Driver
    ../Drivers/FM33LC0xx_LL_Driver/Src/: fm33lc0xx_ll_adc.c fm33lc0xx_ll_aes.c fm33lc0xx_ll_atim.c fm33lc0xx_ll_bstim.c fm33lc0xx_ll_comp.c fm33lc0xx_ll_crc.c fm33lc0xx_ll_dma.c fm33lc0xx_ll_flash.c fm33lc0xx_ll_gpio.c fm33lc0xx_ll_gptim.c fm33lc0xx_ll_hdiv.c fm33lc0xx_ll_i2c.c fm33lc0xx_ll_iwdt.c fm33lc0xx_ll_lcd.c fm33lc0xx_ll_lptim.c fm33lc0xx_ll_lpuart.c fm33lc0xx_ll_opa.c fm33lc0xx_ll_pmu.c fm33lc0xx_ll_rcc.c fm33lc0xx_ll_rng.c fm33lc0xx_ll_rtc.c fm33lc0xx_ll_spi.c fm33lc0xx_ll_svd.c fm33lc0xx_ll_u7816.c fm33lc0xx_ll_uart.c fm33lc0xx_ll_wwdt.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group Mytask
    ../Mytask/usart2/: usart2.c
    ../Mytask/device/: device.c
    ../Mytask/freertostask/: freetask.c
    ../Mytask/hist/: hist.c
    ../Mytask/isl1208/: SD3078.c
    ../Mytask/NB/: nb.c SRNB.c
    ../Mytask/lora/: lora.c
    ../Mytask/jhm1200/: JHM1200_IIC.c
    ../Mytask/modbus/: modbus.c
    ../Mytask/AT/: AT.c
    ../Mytask/timestamp/: timestamp.c
    ../Mytask/pwr/: pwr.c
    ../Mytask/w24q32/: w25qxx.c
    ../Mytask/EC20_4g/: EC20_4g.c
    ../Mytask/lorawan_yxd/: lorawan_yxd.c
    ../Mytask/DS18B20/: DS18B20.c
    ../Mytask/LCD/: LCDdisplay.c
    ../Mytask/CS5560/: CS5560.c
